# Keil uVision project pwm.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: pwm +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c time.c time.h key.c key.h nixie.c nixie.h timer0.c timer0.h
