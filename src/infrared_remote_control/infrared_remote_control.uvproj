# Keil uVision project infrared_remote_control.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: infrared_remote_control +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c timer0.c timer0.h LCD1602.c LCD1602.h time.c time.h int0.c int0.h ir.c ir.h
